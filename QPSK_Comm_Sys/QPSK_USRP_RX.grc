options:
  parameters:
    generate_options: qt_gui
    id: QPSK_Simulation
    output_language: python
    title: QPSK_Simulation
  states: {}

blocks:
- name: excess_bw
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: sym_map
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: sym_map
  id: variable
  parameters:
    value: '[1+1j,1-1j,-1+1j,-1-1j]'
  states: {}
- name: sym_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '4'
    type: complex
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: Decoder
    constellation: qpsk
  states: {}
- name: fir_filter_xxx_1_0
  id: fir_filter_xxx
  parameters:
    comment: Decimation Filter
    decim: '4'
    taps: '[1,0,0,0]'
    type: ccc
  states: {}
- name: root_raised_cosine_filter_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: excess_bw
    comment: Pulse Shaping Filter
    decim: '1'
    gain: '1'
    ntaps: '128'
    samp_rate: sym_rate*sps
    sym_rate: sym_rate
    type: fir_filter_ccf
  states: {}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: sym_rate*sps
    center_freq0: 1e9
    dev_addr: addr=192.168.10.2
    gain0: '10'
    samp_rate: sym_rate*sps
    sd_spec0: B:0
    sync: none
    type: fc32
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: receive_symbol
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: receive_float
  states: {}

connections:
- [blocks_char_to_float_1, '0', virtual_sink_2, '0']
- [blocks_multiply_const_vxx_0, '0', digital_constellation_decoder_cb_0, '0']
- [blocks_multiply_const_vxx_0, '0', virtual_sink_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_char_to_float_1, '0']
- [fir_filter_xxx_1_0, '0', blocks_multiply_const_vxx_0, '0']
- [root_raised_cosine_filter_0_0, '0', fir_filter_xxx_1_0, '0']
- [uhd_usrp_source_1, '0', root_raised_cosine_filter_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
